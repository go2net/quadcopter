<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Project\STM32F103\STM32F103.ewp</path>
  </project>
  <batchBuild/>
</workspace>


